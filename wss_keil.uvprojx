# Keil uVision project wss_keil.uvprojx, settings and files
target stm32f030 (ARM-ADS)
  device: STM32F030K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: wss_keil +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group App
    ./SRC/: bsp.c com.c exti.c gpio.c it.c main.c rcc.c si4432.c time.c wl_com.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.5.0
